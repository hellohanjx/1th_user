# Keil uVision project Project.uvproj, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mainboard +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ../bin/BAIXING.BIN ../RVMDK/Output/mainboard.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\bsp_lib;..\UCOSII\port;..\UCOSII\src;..\UCOSII\uC-CPU;..\Libraries\CMSIS;..\User\INCLUDES;..\LCD;..\USR\Global;..\USR;..\USR\FSM;..\USR\Commucation;..\USR\Mdb;..\USR\Drop;..\USR\DriverBoard;..\USR\Flash;..\USR\Card;..\USR\MSG;..\USR\Bsp;..\USR\SetPar;..\User\QRCode;..\USR\MEM;..\USR\QRCode;..\USR\SETUP;..\USR\stm32
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT6: RAM 0x64000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_wwdg.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_spi.c stm32f10x_tim.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USR/stm32/: system_stm32f10x.c
  group UCOSII/source
    ../UCOSII/src/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII/port
    ../UCOSII/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII/CPU
    ../UCOSII/uC-CPU/: cpu.h cpu_a.asm cpu_def.h
  group LCD_RA8875/ILI9805G_FONT
    ../LCD/: font96.c font48.c logo.c
  group LCD_RA8875
    ../LCD/: RA8875.c
  group LCD_ILI9806G
    ../LCD/: ILI9806G.c
  group LCD_12864_FONT
    ../LCD/: fc12864-6.4.c TM12864_font.c
  group LCD_12864_NO_FONT
    ../LCD/: 12864_NOFONT_font.c 12864-NO_FONT.c
  group bsp_lib
    ../LCD/: bsp_lcd.c
    ../bsp_lib/: sys_config.c fsmc_sram.c i2c_ee_dma.c rtc.c tim3.c uart485.c
    ../USR/Bsp/: log.c bsp_ireader.c bsp_commucation.c bsp_key.c bsp_bkp.c
    ../USR/: delay.c
  group SET_WIDGET
    ../USR/FSM/: menu_format.c
  group MEM
    ../USR/MEM/: mem.c
  group MSG
    ../USR/MSG/: msg.c
  group SETUP
    ../USR/SETUP/: setup.c
  group assist
    ../USR/FSM/: assist.c
  group Mdb_equ
    ../USR/Mdb/: bill.c coin.c mdb_driver.c mdb_fram.c
  group Card
    ../USR/Card/: card_reader_fram.c ireader.c
  group Driver_board
    ../USR/DriverBoard/: drv.c drv_fram.c drv_policy.c
  group DROP_check
    ../USR/Drop/: drop_check.c
  group QRCODE
    ../USR/QRCode/: QR_Encode.c
  group FSMM
    ../USR/FSM/: self_check.c welcom.c sale_card.c sale_cardOnline.c check_cardOnline.c sale_qrcode.c trade_cash.c sale_cash.c choose_goods.c menu_2.c menu_1.c vm_info.c set_goods.c test_channel.c set_channel.c set_tempeture.c set_export.c set_apply.c set_vm.c fsm_fram.c vm_simple_info.c set_driverboard.c fsm_statistic.c
  group commucation
    ../USR/Commucation/: com_fram.c pack_dispense.c pack_set_price.c pack_accept_money.c pack_load.c pack_online_pay.c pack_temp_report.c pack_channel_set.c pack_trade_result.c pack_device_set.c pack_state_change.c pack_qrcode.c pack_status_change.c
  group Flash_struct
    ../USR/Commucation/: flash_struct.c
    ../bsp_lib/: SST25VF016BDrv.c
  group GLOBAL
    ../USR/Global/: global.c word.c
  group MAIN_FOLDER
    ../USR/: main.c
    ../USR/stm32/: stm32f10x_it.c
  group Readme
    ./: readme.txt
